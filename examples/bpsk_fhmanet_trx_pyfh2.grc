<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>bpsk_fhmanet_selector_blade</value></param>
<param><key>author</key><value>Jason Noble</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>bladeRF MAC and modem based on J. Malbury's Simple MAC.</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>title</key><value>BPSK Transceiver MAC</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>value</key><value>cen_freq</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>channel_width</value></param>
<param><key>value</key><value>50000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>d_period_ms</value></param>
<param><key>value</key><value>1000 / hop_rate</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>d_sequence_length</value></param>
<param><key>value</key><value>86400</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>hop_rate</value></param>
<param><key>value</key><value>fh_rate</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>rate</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>selector</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ampl</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label</key><value>TX BB amp</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.7</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>arq_timeout</value></param>
<param><key>label</key><value>ARQ timeout</value></param>
<param><key>short_id</key><value>t</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>.1*0 + 0.04</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>msg</key><value>pmt.intern("T")</value></param>
<param><key>period</key><value>1</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>msg</key><value>pmt.intern("T")</value></param>
<param><key>period</key><value>1</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_1</value></param>
<param><key>msg</key><value>pmt.to_pmt(fhmanet.get_hop_freq(d_period_ms, d_sequence_length))</value></param>
<param><key>period</key><value>1000 / hop_rate</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_source</key>
<param><key>id</key><value>blocks_null_source_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0</value></param>
<param><key>host</key><value></value></param>
<param><key>mtu</key><value>mtu</value></param>
<param><key>port</key><value>port</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"TCP_SERVER"</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>bpsk_radio</key>
<param><key>id</key><value>bpsk_radio_0</value></param>
<param><key>access_code_threshold</key><value>0 + 12 + 4*0</value></param>
<param><key>selector</key><value>selector</value></param>
<param><key>sps</key><value>8</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>broadcast_interval</value></param>
<param><key>label</key><value>Broadcast Interval</value></param>
<param><key>short_id</key><value>b</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>cen_freq</value></param>
<param><key>label</key><value>Center Frequency</value></param>
<param><key>short_id</key><value>c</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>914500000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>dest_addr</value></param>
<param><key>label</key><value>Destination address</value></param>
<param><key>short_id</key><value>d</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fh_rate</value></param>
<param><key>label</key><value>Hop rate</value></param>
<param><key>short_id</key><value>r</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>fhmanet_mac</key>
<param><key>id</key><value>fhmanet_mac_0</value></param>
<param><key>timeout</key><value>0.01</value></param>
<param><key>backoff_randomness</key><value>0.05</value></param>
<param><key>exp_backoff</key><value>True</value></param>
<param><key>broadcast_interval</key><value>2.0</value></param>
<param><key>expire_on_arq_failure</key><value>False</value></param>
<param><key>addr</key><value>radio_addr</value></param>
<param><key>maximum_attempts</key><value>10</value></param>
<param><key>node_expiry_delay</key><value>10.0</value></param>
<param><key>only_send_if_alive</key><value>False</value></param>
<param><key>prepend_dummy</key><value>False</value></param>
<param><key>selector</key><value>selector</value></param>
<param><key>sync_timeout</key><value>120</value></param>
<param><key>sync_tx_interval</key><value>120</value></param>
</block>
<block>
<key>mac_virtual_channel_decoder</key>
<param><key>id</key><value>mac_virtual_channel_decoder_0</value></param>
<param><key>channel_count</key><value>3</value></param>
<param><key>chan_map</key><value>[0,1]</value></param>
</block>
<block>
<key>mac_virtual_channel_encoder</key>
<param><key>id</key><value>mac_virtual_channel_encoder_0</value></param>
<param><key>arq</key><value>True</value></param>
<param><key>chan_tracker</key><value></value></param>
<param><key>dest_addr</key><value>dest_addr</value></param>
<param><key>chan_id</key><value>0</value></param>
<param><key>mtu</key><value>mtu</value></param>
<param><key>prepend_dummy</key><value>False</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>max_arq_attempts</value></param>
<param><key>label</key><value>Max ARQ attempts</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>5 * 2</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>mtu</value></param>
<param><key>label</key><value>TCP Socket MTU</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>128</value></param>
</block>
<block>
<key>osmosdr_sink</key>
<param><key>id</key><value>osmosdr_sink_0</value></param>
<param><key>bb_gain0</key><value>10</value></param>
<param><key>freq0</key><value>center_freq</value></param>
<param><key>if_gain0</key><value>10</value></param>
<param><key>gain0</key><value>5</value></param>
<param><key>args</key><value>bladerf=0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>bb_gain0</key><value>20</value></param>
<param><key>freq0</key><value>center_freq</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>gain0</key><value>10</value></param>
<param><key>args</key><value>bladerf=0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>port</value></param>
<param><key>label</key><value>TCP port</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>12345</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>radio_addr</value></param>
<param><key>label</key><value>Local address</value></param>
<param><key>short_id</key><value>l</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rate</value></param>
<param><key>label</key><value>Sample rate</value></param>
<param><key>short_id</key><value>s</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>3e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samps_per_sym</value></param>
<param><key>label</key><value>Samples/symbol</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>4</value></param>
</block>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>fhmanet_mac_0</sink_block_id><source_key>strobe</source_key><sink_key>ctrl_in</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0_0</source_block_id><sink_block_id>bpsk_radio_0</sink_block_id><source_key>strobe</source_key><sink_key>freq_in</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_1</source_block_id><sink_block_id>bpsk_radio_0</sink_block_id><source_key>strobe</source_key><sink_key>freq_in</sink_key></connection>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_socket_pdu_0</source_block_id><sink_block_id>mac_virtual_channel_encoder_0</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>bpsk_radio_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>bpsk_radio_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>bpsk_radio_0</source_block_id><sink_block_id>osmosdr_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>bpsk_radio_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>msg_out</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>bpsk_radio_0</source_block_id><sink_block_id>fhmanet_mac_0</sink_block_id><source_key>msg_out</source_key><sink_key>from_radio</sink_key></connection>
<connection><source_block_id>fhmanet_mac_0</source_block_id><sink_block_id>mac_virtual_channel_decoder_0</sink_block_id><source_key>to_app</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>fhmanet_mac_0</source_block_id><sink_block_id>bpsk_radio_0</sink_block_id><source_key>to_radio</source_key><sink_key>msg_in</sink_key></connection>
<connection><source_block_id>mac_virtual_channel_decoder_0</source_block_id><sink_block_id>blocks_socket_pdu_0</sink_block_id><source_key>out0</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>mac_virtual_channel_encoder_0</source_block_id><sink_block_id>fhmanet_mac_0</sink_block_id><source_key>out</source_key><sink_key>from_app_arq</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>bpsk_radio_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
